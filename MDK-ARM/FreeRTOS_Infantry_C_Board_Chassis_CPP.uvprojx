# Keil uVision project FreeRTOS_Infantry_C_Board_Chassis_CPP.uvprojx, settings and files
target FreeRTOS_Infantry_C_Board_Chassis_CPP (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FreeRTOS_Infantry_C_Board_Chassis_CPP +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User;../../../../AppData/Local/Keil_v5/ARM/ARMCLANG/include;../../../../AppData/Local/Arm/Packs/ARM/CMSIS-DSP/1.15.0/Include;../User/UI/Static;../User/UI/Dynamic;../User/Task
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group User
    ../User/: call_back.cpp can.cpp capacity.cpp clamp.cpp communication.cpp dji_motor.cpp dr16.cpp error_handle.cpp init.cpp pid.cpp simple_math.cpp state_machine.cpp tracking_differentiator.cpp uart.cpp variables.cpp referee.cpp crc.cpp ui.cpp power_limit.cpp
  group User/UI/Static
    ../User/UI/Static/: char_level.cpp char_maxrpm.cpp char_powerlimit.cpp char_visionmode.cpp char_voltage.cpp char_friction.cpp aimed_line.cpp
  group User/UI/Dynamic
    ../User/UI/Dynamic/: value_level.cpp value_maxrpm.cpp value_powerlimit.cpp value_visionmode.cpp value_voltage.cpp chassis_angle_figure.cpp vision_aimed.cpp chassis_follow_mode.cpp
  group User/Task
    ../User/Task/: capacity_task.cpp chassis.cpp ui_task.cpp referee_detect_task.cpp communication_task.cpp error_handle_task.cpp
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.15.0
